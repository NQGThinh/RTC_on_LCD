# Keil uVision project RTC_LCD.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC_LCD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App_Src
    ./: main.c
  group Driver_Inc
    ./: GPIO.h SYSTICK.h stm32f1xx.h I2C.h
  group Driver_Src
    ./: GPIO.c SYSTICK.c I2C.c
  group BSP_Inc
    ./: DS1307.h LCD.h
  group BSP_SRC
    ./: DS1307.c LCD.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
